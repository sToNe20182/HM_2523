# IAR project watch_ref_design.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_SENSOR_BIO_USE; MTK_SENSOR_BIO_USE_MT2511; MT2511_USE_SPI; USE_EXTERNAL_BOOST; MTK_SENSOR_ACCELEROMETER_GYROSCOPE_USE; MTK_SENSOR_ACCELEROMETER_GYROSCOPE_USE_ICM30630; FUSION_HEART_RATE_MONITOR_USE=M_INHOUSE_HEART_RATE_MONITOR; FUSION_BLOOD_PRESSURE_USE=M_INHOUSE_BLOOD_PRESSURE; FUSION_PEDOMETER_USE=ICM_PEDOMETER; SENSOR_FUSTION_TASK_ENABLED; SENSOR_DEMO; MTK_USB_DEMO_ENABLED; DYNAMIC_BITMAP_LOADER; MTK_AT_CMD_DISABLE; __USB_MASS_STORAGE_ENABLE__; MTK_NVDM_ENABLE; MTK_CTP_ENABLE; __BT_DEBUG__; MTK_PORT_SERVICE_ENABLE; MTK_ATCI_VIA_PORT_SERVICE; MTK_AT_CMD_DISABLE; MTK_USB_DEMO_ENABLED; UI_TOUCHGFX; WATCH_DRIVER_DRIVER_V2; FUSION_REPORT_RAW_DATA_ENABLE; SHOW_UCS2; MTK_AUDIO_MP3_ENABLED; MTK_BT_A2DP_SOURCE_ENABLE; MTK_BT_CODEC_ENABLED; MTK_BT_A2DP_ENABLE; MTK_BT_AVRCP_ENABLE; MTK_BT_AVRCP_ENH_ENABLE; MTK_BT_A2DP_SOURCE_SUPPORT
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include; ..\src\ui\gui\include\gui\common; ..\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\driver\board\mt2523_watch\mems_init; ..\..\..\..\..\driver\board\mt2523_watch\lcd; ..\..\..\..\..\driver\board\mt2523_watch\backlight; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\touchgfx\inc; ..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx; ..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx/hal; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\home_screen; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\main_screen; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\setting_screen; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\graph_screen; ..\src\ui\gui\include\gui\model; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\ui\gui\include\gui\database; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\fonts\include; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\images\include; ..\..\..\..\..\project\mt2523_watch\apps\watch_ref_design\src\generated\texts\include; ..\inc\sensor_demo; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default; ..\..\..\..\..\driver\board\component\mems\src\icm30630; ..\..\..\..\..\driver\board\component\mems\src\icm30630\image; ..\..\..\..\..\driver\board\component\mems\src\icm30630\Invn\Devices; ..\..\..\..\..\middleware\MTK\sensor_subsys\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\blood_pressure\inc; ..\..\..\..\..\driver\board\component\common; ..\..\..\..\..\driver\board\component\touch_panel\common\inc; ..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258; ..\..\..\..\..\driver\board\mt2523_watch\keypad\inc; ..\..\..\..\..\driver\board\mt2523_watch\touch_panel\config; ..\..\..\..\..\driver\board\mt2523_watch\touch_panel\it7258; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\inc\gnss_demo; ..\..\..\..\..\middleware\MTK\usb\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc; ..\inc\Notification; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\prebuilt\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp; ..\..\..\..\..\middleware\MTK\bt_notify\inc; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\lzma_decoder\inc; ..\src\ui\gui\include\gui\database; ..\..\..\..\..\middleware\MTK\port_service\inc; ..\inc\ble_find_me_client; ..\..\..\..\..\middleware\MTK\bluetooth_service\inc; ..\src\dt\inc; ..\..\..\..\..\middleware\MTK\atci\inc; ..\src\ui\gui\include\gui\main_menu_screen; ..\inc\AudioPlayer; ..\..\..\..\..\middleware\MTK\bt_source\inc; ..\..\..\..\..\middleware\third_party\fatfs\src; ..\..\..\..\..\middleware\third_party\fatfs\src\portable\mt2523\inc; ..\..\..\..\..\middleware\MTK\bt_sink\inc; ..\..\..\..\..\middleware\MTK\audio\port\mt2523\inc; ..\..\..\..\..\middleware\MTK\audio\mp3_codec\inc; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\middleware\MTK\audio\sbc_codec\inc; ..\..\..\..\..\prebuilt\driver\board\component\audio\inc; ..\inc\bt_connection; ..\..\..\..\..\driver\board\mt25x3_hdk\bt_codec\inc; ..\..\..\..\..\driver\board\component\bt_codec\inc; ..\..\..\..\..\driver\board\component\audio\inc; ..\..\..\..\..\middleware\MTK\audio\sbc_codec\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\prebuilt\driver\board\component\bt_codec\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: watch_ref_design.bin
  ILINK.IlinkOutputFile: watch_ref_design.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group app
    ../src/: bt_app_common.c bt_gattc_discovery.c bt_init.c ept_eint_var.c ept_gpio_var.c gatt_service.c hci_log.c sys_init.c
    ../src/gnss_demo/: epo_demo.c gnss_app.c gnss_bridge_task.c gnss_ring_buffer.c gnss_timer.c gnss_uart_bridge.c
    ../src/sensor_demo/: sensor_demo.c
  group app_enter
    ../src/ui/gui/src/: BoardConfiguration.cpp
    ../src/: main.cpp regions_init.c
  group atci
    ../../../../../middleware/MTK/atci/at_command/: at_command.c at_command_serial_port.c at_command_syslog.c at_command_system.c
    ../../../../../middleware/MTK/atci/src/: atci_adapter.c atci_handler.c atci_main.c
  group audio
    ../../../../../middleware/MTK/audio/src/: audio_codec.c audio_middleware_api.c
    ../../../../../middleware/MTK/audio/port/mt2523/src/: audio_nvdm.c
    ../../../../../middleware/MTK/audio/mp3_codec/src/: mp3_codec.c
    ../../../../../middleware/MTK/audio/sbc_codec/src/: sbc_codec.c
  group audio_player
    ../src/AudioPlayer/: audio_player_main.c
  group battery
    ../src/battery/: battery_message.c
  group battery_management
    ../../../../../middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group ble_find_me_client
    ../src/ble_find_me_client/: ble_find_me_client.c
  group bluetooth
    ../../../../../middleware/third_party/mbedtls/library/: aes.c md5.c
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
  group bluetooth_service
    ../../../../../middleware/MTK/bluetooth_service/src/: bt_device_manager.c bt_device_manager_le.c bt_gatts_service.c
  group board
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt2523_watch/keypad/src/: keypad_custom.c
    ../../../../../driver/board/component/lcm/RM67160/: lcd_RM67160.c
    ../../../../../driver/board/component/lcm/RM69080/: lcd_RM69080.c
    ../../../../../driver/board/mt2523_watch/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt2523_watch/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/mt2523_watch/touch_panel/it7258/: touch_panel_custom_ite.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt_codec
    ../../../../../driver/board/mt25x3_hdk/bt_codec/src/: bt_a2dp_codec.c bt_hfp_codec.c
  group bt_connection_manager
    ../src/bt_connection/: bt_connection_app.cpp
  group bt_notify_service
    ../../../../../middleware/MTK/bt_notify/src/: bt_notify_conversion.c bt_notify_data_parse.c bt_notify_list.c bt_notify_task.c xml_main.c
  group bt_sink
    ../../../../../middleware/MTK/bt_sink/src/: bt_sink_srv.c bt_sink_srv_a2dp.c bt_sink_srv_action.c bt_sink_srv_am_med_mgr.c bt_sink_srv_am_task.c bt_sink_srv_ami.c bt_sink_srv_atci_cmd.c bt_sink_srv_audio_setting.c bt_sink_srv_audio_sync.c bt_sink_srv_audio_tunning.c bt_sink_srv_avrcp.c bt_sink_srv_aws.c bt_sink_srv_common.c bt_sink_srv_conmgr.c bt_sink_srv_custom_db.c bt_sink_srv_db.c bt_sink_srv_hf.c bt_sink_srv_hf_call_manager.c bt_sink_srv_hf_multipoint.c bt_sink_srv_music.c bt_sink_srv_pbapc.c bt_sink_srv_spp.c bt_sink_srv_state_notify.c bt_sink_srv_utils.c
  group bt_source
    ../../../../../middleware/MTK/bt_source/src/: bt_source_srv.c bt_source_srv_a2dp.c bt_source_srv_avrcp.c bt_source_srv_cntx.c bt_source_srv_utils.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group dogp_service
    ../../../../../middleware/MTK/bt_notify/src/dogp/: ble_dogp_adp_service.c ble_dogp_common.c ble_dogp_service.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group dynamic_image_load
    ../src/ui/gui/src/database/: DynamicBitmapDatabase.cpp
  group fatfs
    ../../../../../middleware/third_party/fatfs/src/portable/mt2523/src/: diskio.c diskio_sd.c diskio_snand.c
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../middleware/third_party/fatfs/src/option/: syscall.c unicode.c
  group generated_dynamic_images
    ../src/generated/dynamic_images/src/Setting/: btn_cancel_long.cpp btn_cancel_short.cpp btn_yes_short.cpp datepicker_background.cpp list_menu_background.cpp switch_off.cpp switch_on.cpp timepicker_background.cpp
    ../src/generated/dynamic_images/src/ClockStyle/: clockstyle_clock1_active.cpp clockstyle_clock1_inactive.cpp clockstyle_clock2_active.cpp clockstyle_clock2_inactive.cpp clockstyle_clock3_active.cpp clockstyle_clock3_inactive.cpp
    ../src/generated/dynamic_images/src/Home/: common_background.cpp home_clock_background.cpp home_compound_clock_background.cpp icon_usb.cpp
    ../src/generated/dynamic_images/src/MainMenu/: fmp_start_long.cpp fmp_stop_long.cpp menu_fmp.cpp menu_gps.cpp menu_setting.cpp
    ../src/generated/dynamic_images/src/Player/: player_pause.cpp player_play.cpp player_skip_next.cpp player_skip_previous.cpp player_volume_1.cpp player_volume_2.cpp player_volume_3.cpp player_volume_4.cpp player_volume_5.cpp player_volume_6.cpp player_volume_7.cpp player_volume_background.cpp
  group generated_fonts
    ../src/generated/fonts/src/: ApplicationFontProvider.cpp Font_MavenPro_Medium_28_4bpp.cpp Font_RobotoCondensed_Regular_120_4bpp.cpp Font_RobotoCondensed_Regular_14_4bpp.cpp Font_RobotoCondensed_Regular_24_4bpp.cpp Font_RobotoCondensed_Regular_28_4bpp.cpp Font_RobotoCondensed_Regular_30_4bpp.cpp Font_RobotoCondensed_Regular_32_4bpp.cpp Font_RobotoCondensed_Regular_35_4bpp.cpp Font_RobotoCondensed_Regular_70_4bpp.cpp FontGetters.cpp Kerning_MavenPro_Medium_28_4bpp.cpp Kerning_RobotoCondensed_Regular_120_4bpp.cpp Kerning_RobotoCondensed_Regular_14_4bpp.cpp Kerning_RobotoCondensed_Regular_24_4bpp.cpp Kerning_RobotoCondensed_Regular_28_4bpp.cpp Kerning_RobotoCondensed_Regular_30_4bpp.cpp Kerning_RobotoCondensed_Regular_32_4bpp.cpp Kerning_RobotoCondensed_Regular_35_4bpp.cpp Kerning_RobotoCondensed_Regular_70_4bpp.cpp Table_MavenPro_Medium_28_4bpp.cpp Table_RobotoCondensed_Regular_120_4bpp.cpp Table_RobotoCondensed_Regular_14_4bpp.cpp Table_RobotoCondensed_Regular_24_4bpp.cpp Table_RobotoCondensed_Regular_28_4bpp.cpp Table_RobotoCondensed_Regular_30_4bpp.cpp Table_RobotoCondensed_Regular_32_4bpp.cpp Table_RobotoCondensed_Regular_35_4bpp.cpp Table_RobotoCondensed_Regular_70_4bpp.cpp
  group generated_images
    ../src/generated/images/src/Setting/: bg_btconnection_item_newdevice.int.cpp datepicker_glass_overlay.int.cpp list_icon_0.int.cpp list_icon_1.int.cpp list_icon_2.int.cpp list_icon_3.int.cpp list_icon_4.int.cpp list_icon_5.int.cpp list_icon_6.int.cpp list_icon_7.int.cpp list_menu_overlay.int.cpp timepicker_glass_overlay.int.cpp
    ../src/generated/images/src/: BitmapDatabase.cpp
    ../src/generated/images/src/Home/: clock_hour_hand.int.cpp clock_minute_hand.int.cpp clock_second_hand.int.cpp compound_clock_center_dot.int.cpp compound_clock_hour_hand.int.cpp compound_clock_minute_hand.int.cpp compound_clock_second_hand.int.cpp icon_android.int.cpp icon_battery.int.cpp icon_battery_charging.int.cpp icon_battery_charging_small.int.cpp icon_battery_small.int.cpp icon_ios.int.cpp
    ../src/generated/images/src/MainMenu/: icon_large_heart.int.cpp icon_small_heart.int.cpp screen_swipe_dots_active.int.cpp screen_swipe_dots_inactive.int.cpp
    ../src/generated/images/src/Player/: player_add_circle.int.cpp player_add_circle_disable.int.cpp player_remove_circle.int.cpp player_remove_circle_disable.int.cpp player_volume.int.cpp player_volume_off.int.cpp
  group generated_texts
    ../src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gnss
    ../../../../../middleware/MTK/gnss/src/: gnss_api.c gnss_driver.c
    ../../../../../driver/board/mt25x3_hdk/gnss/: gnss_config.c
  group gui
    ../src/ui/gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterColoredBitmap.cpp PainterVerticalAlpha.cpp
    ../src/ui/gui/src/setting_screen/: BTDeviceListPresenter.cpp BTDeviceListView.cpp BTDeviceOpPresenter.cpp BTDeviceOpView.cpp BTDeviceSearchListView.cpp BTDeviceSerachListPresenter.cpp DatePicker.cpp HorizontalSlideMenu.cpp MenuListElement.cpp ScreenTimeoutPresenter.cpp ScreenTimeoutView.cpp SetBluetoothPresenter.cpp SetBluetoothView.cpp SetClockPresenter.cpp SetClockView.cpp SetDatePresenter.cpp SetDateView.cpp SetGPSPresenter.cpp SetGPSView.cpp SetHeartRatePresenter.cpp SetHeartRateView.cpp SetTimePresenter.cpp SetTimeView.cpp SettingPresenter.cpp SettingView.cpp SetUSBModePresenter.cpp SetUSBModeView.cpp TimePicker.cpp WheelSelector.cpp WheelSelectorExtra.cpp
    ../src/ui/gui/src/common/: CommonService.cpp DemoPresenter.cpp FrontendApplication.cpp
    ../src/ui/gui/src/main_menu_screen/: DotIndicator.cpp MainMenuPresenter.cpp MainMenuView.cpp SwipeContainer.cpp
    ../src/ui/gui/src/database/: heart_rate_db.cpp
    ../src/ui/gui/src/home_screen/: HomePresenter.cpp HomeView.cpp MassStoragePresenter.cpp MassStorageView.cpp NotificationListPresenter.cpp NotificationListView.cpp
    ../src/ui/gui/src/model/: Model.cpp
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt2523/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: os_port_callback.c
  group lib
    ../../../../../prebuilt/middleware/MTK/audio/mp3_codec/lib/arm_cm4/: lib_mp3dec_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/ble_ancs/lib/: libbleancs_IAR.a
    ../../../../../prebuilt/driver/board/component/audio/lib/arm_cm4/: libblisrc_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_a2dp_iar.a libbt_avrcp_enhance_iar.a libbt_avrcp_iar.a libbt_driver_2523_iar.a libbt_iar.a libbt_spp_iar.a
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_IAR.a
    ../../../../../prebuilt/driver/board/component/bt_codec/lib/arm_cm4/: libcvsd_codec_CM4_IAR.a libmsbc_codec_CM4_IAR.a libplc_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge_IAR.a
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../../../../../middleware/MTK/audio/sbc_codec/lib/arm_cm4/: libsbc_encoder_CM4_IAR.a
    ../../../../../middleware/third_party/touchgfx/lib/core/cortex_m4f/IAR/: touchgfx_core.a
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group mems
    ../../../../../driver/board/component/mems/src/: bma255_i2c_operation.c bma255_sensor_adaptor.c bma2x2.c icm30630.c mems_bus.c sensor_manager_driver.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/EmbUtils/: DataConverter.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/Devices/: DeviceIcm30xxx.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/FifoProtocol/: FifoProtocolCore.c
    ../../../../../driver/board/component/mems/src/icm30630/Invn/Devices/Drivers/Icm30xxx/: Icm30xxxCmd.c Icm30xxxCtrl.c Icm30xxxFifo.c Icm30xxxLoad.c Icm30xxxLogger.c Icm30xxxSelfTest.c Icm30xxxSetup.c Icm30xxxTransport.c
    ../../../../../driver/board/mt2523_watch/mems_init/: mems_init.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_platform_function.c vsm_sensor_subsys_adaptor.c vsm_spi_operation.c
  group notification
    ../src/Notification/: ble_ancs_app.c bt_ancs_common.c bt_notify_app.c bt_notify_app_list.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group port_service
    ../../../../../middleware/MTK/port_service/src/: serial_port.c serial_port_para.c serial_port_uart.c serial_port_usb.c
  group sensor_dt
    ../src/dt/src/: data_transfer.c
  group sensor_fusion
    ../../../../../middleware/MTK/sensor_subsys/src/algo_adaptor/: algo_adaptor.c blood_pressure_monitor_adaptor.c heart_rate_monitor_adaptor.c icm_pedometer_adaptor.c
    ../../../../../prebuilt/middleware/MTK/fusion_algo/blood_pressure/lib_core/: libbp_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/common/lib_core/: libcomm_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/heart_rate/lib_core/: libhr_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/lib_core/: libppgctrl_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/module/default/: ppg_control_module.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c
  group touchgfxHAL
    ../../../../../middleware/third_party/touchgfx/src/: CortexMMCUInstrumentation.cpp GPIO.cpp mt2523DMA.cpp mt2523HAL.cpp OSWrappers.cpp
    ../src/touch_adapter/: mt2523TouchController.cpp
  group usb
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
    ../../../../../middleware/MTK/usb/src/msc/: usbms_adap.c usbms_drv.c usbms_msdc.c usbms_state.c
