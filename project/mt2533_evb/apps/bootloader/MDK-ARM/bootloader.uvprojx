# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: ..\..\..\..\..\tools\keil\srecord-1.64-win32\srec_cat.exe $L@L.bin -Binary -offset 0x08000000 -o $L@L.hex -Intel
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BL_DEBUG BL_FOTA_ENABLE BL_LOAD_ENABLE __UBL__ __EXT_BOOTLOADER__ MBEDTLS_CONFIG_FILE='<config-mtk-sha1.h>' BL_LOG_VIA_UART0 MTK_EXTERNAL_PMIC_TYPE_MT6327
  c misc: --c99
  c include: .\;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\board\mt25x3_hdk\bootloader\core\inc;..\..\..\..\..\driver\board\mt25x3_hdk\emi\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\project\mt2533_evb\apps\bootloader\inc;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\middleware\third_party\lzma_decoder\inc;..\..\..\..\..\driver\board\mt25x3_hdk\bootloader\core\inc\pmic;..\..\..\..\..\middleware\third_party\fatfs\src;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\ram.sct
  group bootloader
    ../../../../../driver/board/mt25x3_hdk/bootloader/core/src/: bl_clock.c bl_dbgprint.c bl_dcxo_cal.c bl_fota.c bl_gpt.c bl_main.c bl_misc.c bl_uart.c custom_blconfig.c bl_usb.c bl_pmic.c bl_msdc.c bl_sd.c bl_sd_internal.c bl_wdt.c
    ./: startup_bootloader.s
    ../../../../../driver/board/mt25x3_hdk/bootloader/core/src/pmic/: bl_max14745.c bl_mt6385.c bl_mt6327.c
  group emi
    ../../../../../driver/board/mt25x3_hdk/emi/src/: emi_init.c memory_test.c
  group flash
    ../../../../../driver/chip/mt2523/src/: hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_cache.c hal_cache_internal.c hal_nvic_internal.c
  group i2c
    ../../../../../driver/chip/mt2523/src/: hal_i2c_master_internal.c hal_i2c_pmic.c
  group sha1
    ../../../../../middleware/third_party/mbedtls/library/: sha1.c
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group fatfs
    ../../../../../middleware/third_party/fatfs/src/: ff.c
    ../../../../../middleware/third_party/fatfs/src/option/: syscall.c unicode.c
    ../../../../../middleware/third_party/fatfs/src/portable/mt2533/bootloader/src/: diskio.c
